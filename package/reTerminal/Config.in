## package/reTerminal/Config.in
```kconfig
config BR2_PACKAGE_RETERMINAL
	bool "reTerminal"
	depends on BR2_LINUX_KERNEL
	help
		Drivers for reTerminal
```
